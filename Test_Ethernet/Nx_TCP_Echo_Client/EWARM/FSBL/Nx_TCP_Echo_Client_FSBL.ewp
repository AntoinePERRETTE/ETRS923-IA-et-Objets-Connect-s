# IAR project Nx_TCP_Echo_Client_FSBL.ewp, settings and files
configuration Nx_TCP_Echo_Client_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; NX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_SECURE=1
  ICCARM.CCIncludePath2: ../../FSBL/NetXDuo/App; ../../FSBL/NetXDuo/Target; ../../FSBL/Core/Inc; ../../FSBL/AZURE_RTOS/App; ../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../Middlewares/ST/netxduo/addons/dhcp; ../../Middlewares/ST/netxduo/common/drivers/ethernet; ../../Middlewares/ST/threadx/common/inc; ../../Middlewares/ST/netxduo/common/inc; ../../Middlewares/ST/netxduo/ports/cortex_m55/iar/inc; ../../Middlewares/ST/threadx/ports/cortex_m55/iar/inc; ../../Drivers/CMSIS/Include; ../../Middlewares/ST/netxduo/tsn/inc; ../../Drivers/BSP/Components/lan8742; ../../Middlewares/ST/netxduo/addons/dns
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_SECURE=1
  AARM.AUserIncludes: ../../FSBL/NetXDuo/App; ../../FSBL/NetXDuo/Target; ../../FSBL/Core/Inc; ../../FSBL/AZURE_RTOS/App; ../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../Drivers/BSP/Components/lan8742; ../../Middlewares/ST/netxduo/tsn/inc; ../../Middlewares/ST/netxduo/addons/dhcp; ../../Middlewares/ST/netxduo/common/drivers/ethernet; ../../Middlewares/ST/threadx/common/inc; ../../Middlewares/ST/netxduo/common/inc; ../../Middlewares/ST/netxduo/ports/cortex_m55/iar/inc; ../../Middlewares/ST/netxduo/addons/dns; ../../Middlewares/ST/threadx/ports/cortex_m55/iar/inc; ../../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: Nx_TCP_Echo_Client_FSBL.bin
  ILINK.IlinkOutputFile: Nx_TCP_Echo_Client_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL/AZURE_RTOS/App
    ../../FSBL/AZURE_RTOS/App/: app_azure_rtos.c
  group Application/User/FSBL/NetXDuo/App
    ../../FSBL/NetXDuo/App/: app_netxduo.c
  group Application/User/FSBL/Core
    ../../FSBL/Core/Src/: main.c tx_initialize_low_level.S app_threadx.c stm32n6xx_it.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/lan8742/: lan8742.c
  group Doc
    ../../: README.md
